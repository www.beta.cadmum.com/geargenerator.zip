# Autodesk Inventor assembly: GearBox_New
## iProperties
Created: 2007-11
Part Number: GearBox_New
Document SubType Name: Assembly
Designer: CM
Author: CM
